IMAGE_INSTALL:append = " aes-gcm-rx pcam-aes-bridge kernel-module-pcam-aes-bridge aes-session-agent linux-firmware-mt7601u iw wpa-supplicant rfkill usbutils iperf3"
