FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://pcam.cfg file://wireless.cfg"
