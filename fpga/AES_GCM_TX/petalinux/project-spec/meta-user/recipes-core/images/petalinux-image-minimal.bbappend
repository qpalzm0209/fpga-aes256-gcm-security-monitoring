# Exact 1472-byte AES-GCM UDP record transmitter and camera inspection tools.
IMAGE_INSTALL:append = " pcam-gcm-tx aes-session-agent v4l-utils media-ctl linux-firmware-mt7601u iw wpa-supplicant rfkill usbutils iperf3"
