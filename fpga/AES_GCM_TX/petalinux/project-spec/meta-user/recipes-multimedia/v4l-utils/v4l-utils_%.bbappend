# Direct UYVY8_1X16 uses an upstream media-bus code.  No v4l-utils patch is
# required; this empty bbappend intentionally supersedes the preserved RAW10
# overlay's RBG101010 media-ctl extension.
